# Keil uVision project IO_Extend_51.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: IO_Extend_51 +hex
  group Main
    ./lib/: STC32G_UART_Isr.c
    ./source/: main.c ReceiveData.c queue.c
  group Lib
    ./lib/: STC32G_ADC.c STC32G_Delay.c STC32G_GPIO.c STC32G_NVIC.c STC32G_UART.c
